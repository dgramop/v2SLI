# Repository dgramop/v2SLI

## KiCad design v2SLI.kicad_pcb

Parts:
C1, C4, C5, C6, C7: C; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C3: C VCAP; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8: CAP; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3, D4, D5: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Inter-MCU Interrupts Header; PinHeader_1x02_P2.54mm_Vertical
J2: Inter-MCU UART Header; PinHeader_1x02_P2.54mm_Vertical
J3, J16: SPI Bus; PinHeader_1x03_P2.54mm_Vertical
J4, J19: UART1; PinHeader_1x02_P2.54mm_Vertical
J5: 205GPIOs; PinHeader_1x04_P2.54mm_Vertical
J6: UART2; PinHeader_1x02_P2.54mm_Vertical
J7: I2C1; PinHeader_1x02_P2.54mm_Vertical
J8, J9: Conn_02x15_Top_Bottom; PinHeader_2x15_P2.54mm_Vertical
J10: Programming Header for 205; PinSocket_1x04_P2.54mm_Vertical
J11, J15: Boot 0; PinHeader_1x03_P2.54mm_Vertical
J12, J13: Boot 1; PinHeader_1x03_P2.54mm_Vertical
J14: Programming Header for 103; PinHeader_1x04_P2.54mm_Vertical
J17: Enable Fix; PinHeader_1x03_P2.54mm_Vertical
J18: GPIOs; PinHeader_1x04_P2.54mm_Vertical
J20: Micro_SD_Card; 1140084168
J21: Radio UART; PinHeader_1x02_P2.54mm_Vertical
J22: VCC RAIL; SolderWirePad_1x01_Drill2mm
J23: GND RAIL; SolderWirePad_1x01_Drill2mm
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13: R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1, SW2, SW3: SW_Push; PinHeader_1x02_P2.54mm_Vertical
U1: STM32F205RETx; LQFP-64_10x10mm_P0.5mm
U2, U3: BMP388; PQFN50P200X200X80-10N
U4: ICM20948; QFN-24-1EP_3x3mm_P0.4mm_EP1.75x1.6mm
U5: TCR2EE185-SOT553; SOT-553
U6: ADA746; PinSocket_1x09_P2.54mm_Vertical
U7: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U8: Xbee; DIP2200W51P200L3294H279Q20P

Connections:
/103BOOT0: J15.2, U7.44 (BOOT0)
/103BOOT1: J13.2, U7.20 (PB2)
/205BOOT0: J11.2, U1.60 (BOOT0)
/205BOOT1: J12.2, U1.28 (PB2)
/205CLKSPI: J3.3, U1.21 (PA5), U2.2 (SCK), U3.2 (SCK), U4.23
/205MISOSPI: J3.2, U1.22 (PA6), U2.5 (SDO), U3.5 (SDO), U4.9
/205MOSISPI: J3.1, U1.23 (PA7), U2.4 (SDI), U3.4 (SDI), U4.24
/205SCLI2C: J7.2, U1.58 (PB6)
/205SDAI2C: J7.1, U1.59 (PB7)
/ACCINT: U1.26 (PB0), U4.12
/BMP0CS: U1.33 (PB12), U2.6 (CSB)
/BMP1CS: U1.34 (PB13), U3.6 (CSB)
/CLK103SPI: J16.3, J20.5 (CLK), U7.39 (PB3)
/CSSD: J20.2 (DAT3/CD), U7.32 (PA11)
/GPSEnable: J17.2, U6.2 (EN), U7.29 (PA8)
/GPSFix: J17.3, U6.4 (FIX), U7.38 (PA15)
/GPSRX103TX: J19.1, U6.6 (RX), U7.30 (PA9)
/GPSTX103RX: J19.2, U6.5 (TX), U7.31 (PA10)
/ICMCS: U1.35 (PB14), U4.22
/MISO103SPI: J16.2, J20.7 (DAT0), U7.40 (PB4)
/MOSI103SPI: J16.1, J20.3 (CMD), U7.41 (PB5)
/PA0: J18.3, U7.10 (PA0)
/PA1: J18.4, U7.11 (PA1)
/PB0: J18.1, U7.18 (PB0)
/PB1: J18.2, U7.19 (PB1)
/PPS: J17.1, U1.36 (PB15), U6.9 (PPS), U7.33 (PA12)
/RFRX103TX: J21.1, U7.12 (PA2), U8.3 (DIN/CONFIG)
/RFTX103RX: J21.2, U7.13 (PA3), U8.2 (DOUT)
/RX205TX103: J2.1, U1.30 (PB11), U7.21 (PB10)
/SWCLK103: J14.1, R9.1, U7.37 (PA14)
/SWCLK205: J10.1, R7.1, U1.49 (PA14)
/SWIO103: J14.2, R8.1, U7.34 (PA13)
/SWIO205: J10.2, R6.1, U1.46 (PA13)
/TX205RX103: J2.2, U1.29 (PB10), U7.22 (PB11)
/UART1RX: J4.1, U1.43 (PA10)
/UART1TX: J4.2, U1.42 (PA9)
/UART2RX: J6.1, U1.17 (PA3)
/UART2TX: J6.2, U1.16 (PA2)
/VDDIOACC: C5.1, U4.8, U5.4 (Vout)
/f103int: J1.1, U1.37 (PC6), U7.26 (PB13)
/f205int: J1.2, U1.38 (PC7), U7.25 (PB12)
/vdivider: J5.1, R2.2, R3.1, U1.8 (PC0)
GND: C1.1, C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, D5.1 (K), J10.3, J11.1, J12.1, J13.1, J14.3, J15.1, J20.6 (VSS), J23.1, R3.2, R4.2, R5.2, R7.2, R9.2, R11.2, R12.2, SW1.2, SW2.2, SW3.1, U1.12 (VSSA), U1.18 (VSS), U1.63 (VSS), U2.3 (VSS), U2.8 (VSS), U2.9 (VSS), U3.3 (VSS), U3.8 (VSS), U3.9 (VSS), U4.18, U4.20, U5.2 (GND), U6.7 (GND), U7.8 (VSSA), U7.23 (VSS), U7.35 (VSS), U7.47 (VSS), U8.10 (GND)
unnamed: C1.2, R1.1, SW1.1, U1.7 (NRST)
unnamed: C2.1, U1.31 (VCAP_1)
unnamed: C3.1, U1.47 (VCAP_2)
unnamed: C4.2, R10.1, SW2.1, U7.7 (NRST)
unnamed: D1.1 (K), R4.1
unnamed: D1.2 (A), U1.39 (PC8)
unnamed: D2.1 (K), R5.1
unnamed: D2.2 (A), U1.40 (PC9)
unnamed: D3.1 (K), R11.1
unnamed: D3.2 (A), U7.27 (PB14)
unnamed: D4.1 (K), R12.1
unnamed: D4.2 (A), U7.28 (PB15)
unnamed: D5.2 (A), R13.2
unnamed: J5.2, U1.9 (PC1)
unnamed: J5.3, U1.10 (PC2)
unnamed: J5.4, U1.11 (PC3)
unnamed: J8.1, J9.1
unnamed: J8.2, J9.2
unnamed: J8.3, J9.3
unnamed: J8.4, J9.4
unnamed: J8.5, J9.5
unnamed: J8.6, J9.6
unnamed: J8.7, J9.7
unnamed: J8.8, J9.8
unnamed: J8.9, J9.9
unnamed: J8.10, J9.10
unnamed: J8.11, J9.11
unnamed: J8.12, J9.12
unnamed: J8.13, J9.13
unnamed: J8.14, J9.14
unnamed: J8.15, J9.15
unnamed: J8.16, J9.16
unnamed: J8.17, J9.17
unnamed: J8.18, J9.18
unnamed: J8.19, J9.19
unnamed: J8.20, J9.20
unnamed: J8.21, J9.21
unnamed: J8.22, J9.22
unnamed: J8.23, J9.23
unnamed: J8.24, J9.24
unnamed: J8.25, J9.25
unnamed: J8.26, J9.26
unnamed: J8.27, J9.27
unnamed: J8.28, J9.28
unnamed: J8.29, J9.29
unnamed: J8.30, J9.30
unnamed: SW3.2, U8.5 (RESET)
VCC: C6.1, C7.1, C8.1, J10.4, J11.3, J12.3, J13.3, J14.4, J15.3, J20.4 (VDD), J22.1, R1.2, R2.1, R6.2, R8.2, R10.2, R13.1, U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U2.1 (VDDIO), U2.10 (VDD), U3.1 (VDDIO), U3.10 (VDD), U4.13, U5.1 (control), U5.3 (Vin), U6.8 (VIN), U7.1 (VBAT), U7.9 (VDDA), U7.24 (VDD), U7.36 (VDD), U7.48 (VDD), U8.1 (VCC)

Notes on the sheet:
route accint?

Board: 2 copper layers, 77.7 x 75.9 mm, 60 parts (0 on the bottom side), 91 nets.

## Commit log

2020-02-17 Speedrun PCB redesign
2020-02-17 some info for jonny
2020-02-18 added a zip of a few footprints that I hadn't proplery imported.
    I designed this in a rush and didn't really bother to get the footprints properly in there, just got the same settings from SLI v1. Now I know for future projects
2020-02-18 added some rando holes, will adjust when I talk to jonny
2020-02-18 got rid of some unconnected stuff
2020-02-18 Ran DRC, no major fixable issues. Via near track for VDDIO and VCC, this may be a problem but unlikely given the manufacturers we'll be using
2020-02-20 added some images from images library
2020-02-21 Added some logos for our sponsors and some holes for mouting
2020-02-21 some more logo stuff. sending to oshpark this time
2020-03-08 Fixed some shorts that resulted in MOSI being pulled low.
    For some reason Kicad didn't enforce the netlist? didn't catch in DRC?
2020-03-08 changed origins
